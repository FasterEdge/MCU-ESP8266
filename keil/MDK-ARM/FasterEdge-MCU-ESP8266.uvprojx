# Keil uVision project FasterEdge-MCU-ESP8266.uvprojx, settings and files
target FasterEdge-MCU-ESP8266 (ARM-ADS)
  device: ESP8266 Espressif
  cpu: IRAM(0x40080000-0x4009FFFF) IRAM(0x400A0000-0x400BFFFF) IROM(0x400D0000-0x400DFFFF) XROM(0x40000000-0x4007FFFF) XROM(0x400C0000-0x400CFFFF) CLOCK=24000000
  output: FasterEdge-MCU-ESP8266
  group Core
    ../Core/: fe.c fe_hmac_sha256.c
  group Ability
    ../Ability/: ability_base.c ability_role.c ability_time.c ability_onekey.c ability_configfile.c ability_serial.c ability_mqtt.c ability_modbus.c ability_edgerole.c
  group Data
    ../Data/: data_base.c data_config.c data_keyring.c data_netmap.c
  group User
    ../User/: main.c register.c fe_port.c
